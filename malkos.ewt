<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>MSP430</name>
    </toolchain>
    <debug>1</debug>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>MSP430</name>
    </toolchain>
    <debug>0</debug>
  </configuration>
  <file>
    <name>$PROJ_DIR$\flash.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\flash.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\main.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\main.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\UART_functions.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\UART_functions.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\UART_settings.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\UART_settings.h</name>
  </file>
</project>


